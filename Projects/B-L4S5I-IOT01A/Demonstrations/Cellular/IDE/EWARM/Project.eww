<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\prj_NBIOT_L4S5I.ewp</path>
  </project>
  <batchBuild />
</workspace>
