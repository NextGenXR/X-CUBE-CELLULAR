# Keil uVision project prj_NBIOT_L4S5I.uvprojx, settings and files
target L4S5I_IOT01_BG96 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L4S5VITx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IROM(0x08000000-0x81FFFFF) IRAM(0x20000000-0x2009FFFF) IRAM2(0x20000000-0x2002FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: prj_NBIOT_L4S5I
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L4S5xx,HAS_RTOS,USER_FLAG_MODEM_FORCE_NO_FLOW_CTRL,HWREF_B_CELL_BG96_V2,APPLICATION_CONFIG_FILE=<plf_cellular_app_config.h>,APPLICATION_THREAD_CONFIG_FILE=<plf_cellular_app_thread_config.h>
  c include: ../../Core/Inc;../../STM32_Cellular/Config;../../STM32_Cellular/Target;../../../../../Misc/Cmd/Inc;../../../../../Misc/RTOS/FreeRTOS/Inc;../../../../../Misc/Samples/Cellular/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/X_STMOD_PLUS_MODEMS/BG96/AT_modem_bg96/Inc;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../../../../../../Middlewares/ST/STM32_Cellular/Core/AT_Core/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Core/Cellular_Service/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Core/Data_Cache/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Core/Error/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Core/Ipc/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Core/PPPosif/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Core/Runtime_Library/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Core/Rtosal/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Core/Trace/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Interface/Cellular_Ctrl/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Interface/Com/Inc;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../../Middlewares/Third_Party/LwIP/system/arch;../../../../../../Middlewares/Third_Party/LwIP/src/include;../../../../../../Middlewares/Third_Party/LwIP/src/include/lwip/prot;../../../../../../Middlewares/Third_Party/LwIP/src/include/netif/ppp;../../../../../../Middlewares/Third_Party/LwIP/system
  asm include: ../Core/Inc;../../STM32_Cellular/Config;../../../../../Misc/RTOS/FreeRTOS/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Application/MDK-ARM
    ./: startup_stm32l4s5xx.s
  group Application/User
    ../../Core/Src/: gpio.c main.c rng.c rtc.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c stm32l4xx_it.c usart.c
  group Drivers/BSP/X_STMOD_PLUS_MODEMS/BG96
    ../../../../../../Drivers/BSP/X_STMOD_PLUS_MODEMS/BG96/AT_modem_bg96/Src/: at_custom_modem_api.c at_custom_modem_signalling.c at_custom_modem_socket.c at_custom_modem_specific.c sysctrl_specific.c
  group Drivers/BSP/X_STMOD_PLUS_MODEMS/MONARCH
    ../../../../../../Drivers/BSP/X_STMOD_PLUS_MODEMS/MONARCH/AT_modem_monarch/Src/: at_custom_modem_api.c at_custom_modem_signalling.c at_custom_modem_socket.c at_custom_modem_specific.c sysctrl_specific.c
  group Drivers/CMSIS
    ../../Core/Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rng_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Middlewares/Cellular/Core/AT_Core
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/AT_Core/Src/: at_core.c at_datapack.c at_modem_api.c at_modem_common.c at_modem_signalling.c at_modem_socket.c at_parser.c at_util.c sysctrl.c
  group Middlewares/Cellular/Core/Cellular_Service
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/Cellular_Service/Src/: cellular_service.c cellular_service_cmd.c cellular_service_config.c cellular_service_datacache.c cellular_service_int.c cellular_service_os.c cellular_service_power.c cellular_service_task.c cellular_service_utils.c
  group Middlewares/Cellular/Core/Data_Cache
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/Data_Cache/Src/: dc_common.c
  group Middlewares/Cellular/Core/Error
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/Error/Src/: error_handler.c
  group Middlewares/Cellular/Core/HW_Specific
    ../../STM32_Cellular/Target/: board_interrupts.c
  group Middlewares/Cellular/Core/Ipc
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/Ipc/Src/: ipc_common.c ipc_rxfifo.c ipc_uart.c
  group Middlewares/Cellular/Core/PPPosif
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/PPPosif/Src/: ppposif.c ppposif_client.c ppposif_ipc.c
  group Middlewares/Cellular/Core/Rtosal
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/Rtosal/Src/: rtosal.c
  group Middlewares/Cellular/Core/Runtime_Library
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/Runtime_Library/Src/: cellular_runtime_custom.c cellular_runtime_standard.c
  group Middlewares/Cellular/Core/Trace
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/Trace/Src/: trace_interface.c
  group Middlewares/Cellular/Interface/Com
    ../../../../../../Middlewares/ST/STM32_Cellular/Interface/Com/Src/: com_core.c com_icc.c com_sockets.c com_sockets_err_compat.c com_sockets_ip_modem.c com_sockets_lwip_mcu.c com_sockets_statistic.c
  group Middlewares/Cellular/Interface/Control
    ../../../../../../Middlewares/ST/STM32_Cellular/Interface/Cellular_Ctrl/Src/: cellular_control_api.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/Third_Party/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/Third_Party/LwIP/api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/Third_Party/LwIP/core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Middlewares/Third_Party/LwIP/core/ipv4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Middlewares/Third_Party/LwIP/netif/ppp
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppos.c upap.c utils.c vj.c
  group Middlewares/Third_Party/LwIP/system/OS
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Misc/Cmd
    ../../../../../Misc/Cmd/Src/: cmd.c
  group Misc/Freertos
    ../../../../../Misc/RTOS/FreeRTOS/Src/: freertos.c
  group Misc/Samples/Cellular
    ../../../../../Misc/Samples/Cellular/Src/: cellular_app.c cellular_app_cmd.c cellular_app_datetime.c cellular_app_echoclient.c cellular_app_pingclient.c cellular_app_socket.c
    ../../../../../Misc/Samples/Cellular/Inc/: plf_cellular_app_config.h plf_cellular_app_thread_config.h
target L4S5I_IOT01_GM01Q (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L4S5VITx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: as above
  output: prj_NBIOT_L4S5I
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L4S5xx,HAS_RTOS,USER_FLAG_MODEM_FORCE_NO_FLOW_CTRL,HWREF_GM01QDBA1,APPLICATION_CONFIG_FILE=<plf_cellular_app_config.h>,APPLICATION_THREAD_CONFIG_FILE=<plf_cellular_app_thread_config.h>
  c include: ../../Core/Inc;../../STM32_Cellular/Config;../../STM32_Cellular/Target;../../../../../Misc/Cmd/Inc;../../../../../Misc/RTOS/FreeRTOS/Inc;../../../../../Misc/Samples/Cellular/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/X_STMOD_PLUS_MODEMS/MONARCH/AT_modem_monarch/Inc;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../../../../../../Middlewares/ST/STM32_Cellular/Core/AT_Core/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Core/Cellular_Service/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Core/Data_Cache/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Core/Error/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Core/Ipc/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Core/PPPosif/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Core/Runtime_Library/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Core/Rtosal/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Core/Trace/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Interface/Cellular_Ctrl/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Interface/Com/Inc;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../../Middlewares/Third_Party/LwIP/system/arch;../../../../../../Middlewares/Third_Party/LwIP/src/include;../../../../../../Middlewares/Third_Party/LwIP/src/include/lwip/prot;../../../../../../Middlewares/Third_Party/LwIP/src/include/netif/ppp;../../../../../../Middlewares/Third_Party/LwIP/system
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
target L4S5I_IOT01_BG96_LwIP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L4S5VITx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: as above
  output: prj_NBIOT_L4S5I
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L4S5xx,HAS_RTOS,USER_FLAG_MODEM_FORCE_NO_FLOW_CTRL,HWREF_B_CELL_BG96_V2,APPLICATION_CONFIG_FILE=<plf_cellular_app_config.h>,APPLICATION_THREAD_CONFIG_FILE=<plf_cellular_app_thread_config.h>,USE_SOCKETS_TYPE=USE_SOCKETS_LWIP,USE_LOW_POWER=0
  c include: ../../Core/Inc;../../STM32_Cellular/Config;../../STM32_Cellular/Target;../../../../../Misc/Cmd/Inc;../../../../../Misc/RTOS/FreeRTOS/Inc;../../../../../Misc/Samples/Cellular/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/X_STMOD_PLUS_MODEMS/BG96/AT_modem_bg96/Inc;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../../Middlewares/Third_Party/LwIP/system/arch;../../../../../../Middlewares/Third_Party/LwIP/src/include;../../../../../../Middlewares/Third_Party/LwIP/src/include/lwip/prot;../../../../../../Middlewares/Third_Party/LwIP/src/include/netif/ppp;../../../../../../Middlewares/Third_Party/LwIP/system;../../../../../../Middlewares/ST/STM32_Cellular/Core/AT_Core/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Core/Cellular_Service/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Core/Data_Cache/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Core/Error/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Core/Ipc/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Core/PPPosif/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Core/Runtime_Library/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Core/Rtosal/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Core/Trace/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Interface/Cellular_Ctrl/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Interface/Com/Inc
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
target Jenkins_Config (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L4S5VITx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: as above
  output: prj_NBIOT_L4S5I
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: as above
  c include: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
software components: CMSIS:CORE 4.3.0
