# Keil uVision project Prj_Murata_L462.uvprojx, settings and files
target DiscoL462_T1SC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L462RETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x20027FFF) IRAM2(0x20000000-0x2001FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: DiscoL462_T1SC
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L462xx,USE_STM32L462E_CELL01,DISCO_L462,APPLICATION_CONFIG_FILE=<plf_cellular_app_iot_config.h>,APPLICATION_THREAD_CONFIG_FILE=<plf_cellular_app_iot_thread_config.h>,APPLICATION_IMAGES_FILE=<cellular_app_bmp_images.h>
  c include: ../../Core/Inc;../../STM32_Cellular/Config;../../STM32_Cellular/Target;../../../../../Misc/Cmd/Inc;../../../../../Misc/Ndlc/Core/Inc;../../../../../Misc/Ndlc/Interface/Inc;../../../../../Misc/RTOS/FreeRTOS/Inc;../../../../../Misc/Samples/CellularIoT/Inc;../../../../../Misc/SPI/Inc;../../../../../../Drivers/BSP/B-L462E-CELL1;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/hts221;../../../../../../Drivers/BSP/Components/lps22hh;../../../../../../Drivers/BSP/Components/lsm303agr;../../../../../../Drivers/BSP/Components/ssd1315;../../../../../../Drivers/BSP/X_STMOD_PLUS_MODEMS/TYPE1SC/AT_modem_type1sc/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../../Middlewares/ST/STM32_Cellular/Core/AT_Core/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Core/Cellular_Service/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Core/Data_Cache/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Core/Error/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Core/Ipc/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Core/PPPosif/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Core/Runtime_Library/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Core/Rtosal/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Core/Trace/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Interface/Cellular_Ctrl/Inc;../../../../../../Middlewares/ST/STM32_Cellular/Interface/Com/Inc;../../../../../../Utilities/Fonts;../../../../../../Utilities/LCD
  asm include: ../../Core/Inc;../../STM32_Cellular/Config;../../../../../Misc/RTOS/FreeRTOS/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group Application/MDK-ARM
    ./: startup_stm32l462xx.s
  group Application/User
    ../../Core/Src/: gpio.c i2c.c main.c quadspi.c rng.c rtc.c spi.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_TIM.c stm32l4xx_it.c tim.c usart.c
  group Drivers/BSP/B_L462E_CELL1
    ../../../../../../Drivers/BSP/B-L462E-CELL1/: stm32l462e_cell1.c stm32l462e_cell1_bus.c stm32l462e_cell1_eeprom.c stm32l462e_cell1_env_sensors.c stm32l462e_cell1_env_sensors_ex.c stm32l462e_cell1_lcd.c stm32l462e_cell1_motion_sensors.c stm32l462e_cell1_motion_sensors_ex.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
    ../../../../../../Drivers/BSP/Components/lsm303agr/: lsm303agr.c lsm303agr_reg.c
    ../../../../../../Drivers/BSP/Components/ssd1315/: ssd1315.c
  group Drivers/BSP/X_STMOD_PLUS_MODEMS/TYPE1SC
    ../../../../../../Drivers/BSP/X_STMOD_PLUS_MODEMS/TYPE1SC/AT_modem_type1sc/Src/: at_custom_modem_api.c at_custom_modem_signalling.c at_custom_modem_socket.c at_custom_modem_specific.c sysctrl_specific.c
  group Drivers/CMSIS
    ../../Core/Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_ll_usb.c
  group Middlewares/Cellular/Core/AT_Core
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/AT_Core/Src/: at_core.c at_datapack.c at_modem_api.c at_modem_common.c at_modem_signalling.c at_modem_socket.c at_parser.c at_util.c sysctrl.c
  group Middlewares/Cellular/Core/Cellular_Service
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/Cellular_Service/Src/: cellular_service.c cellular_service_cmd.c cellular_service_config.c cellular_service_int.c cellular_service_os.c cellular_service_power.c cellular_service_task.c cellular_service_utils.c cellular_service_datacache.c
  group Middlewares/Cellular/Core/Data_Cache
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/Data_Cache/Src/: dc_common.c
  group Middlewares/Cellular/Core/Error
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/Error/Src/: error_handler.c
  group Middlewares/Cellular/Core/HW_Specific
    ../../STM32_Cellular/Target/: board_interrupts.c
  group Middlewares/Cellular/Core/Ipc
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/Ipc/Src/: ipc_common.c ipc_rxfifo.c ipc_uart.c
  group Middlewares/Cellular/Core/PPPosif
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/PPPosif/Src/: ppposif.c ppposif_client.c ppposif_ipc.c
  group Middlewares/Cellular/Core/Rtosal
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/Rtosal/Src/: rtosal.c
  group Middlewares/Cellular/Core/Runtime_Library
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/Runtime_Library/Src/: cellular_runtime_custom.c cellular_runtime_standard.c
  group Middlewares/Cellular/Core/Trace
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/Trace/Src/: trace_interface.c
  group Middlewares/Cellular/Interface/Com
    ../../../../../../Middlewares/ST/STM32_Cellular/Interface/Com/Src/: com_core.c com_icc.c com_sockets.c com_sockets_err_compat.c com_sockets_ip_modem.c com_sockets_lwip_mcu.c com_sockets_statistic.c com_utils.c
  group Middlewares/Cellular/Interface/Control
    ../../../../../../Middlewares/ST/STM32_Cellular/Interface/Cellular_Ctrl/Src/: cellular_control_api.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/Third_Party/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Projects/Misc/Cmd
    ../../../../../Misc/Cmd/Src/: cmd.c
  group Projects/Misc/Ndlc
    ../../../../../Misc/Ndlc/Core/Src/: ndlc.c ndlc_commands.c
    ../../../../../Misc/Ndlc/Interface/Src/: spi_ndlc.c
  group Projects/Misc/SPI
    ../../../../../Misc/SPI/Src/: sys_spi.c
  group Projects/Misc/FreeRTOS
    ../../../../../Misc/RTOS/FreeRTOS/Src/: freertos.c
  group Projects/Misc/Samples/Cellular
    ../../../../../Misc/Samples/CellularIoT/Src/: cellular_app.c cellular_app_cmd.c cellular_app_datetime.c cellular_app_display.c cellular_app_echoclient.c cellular_app_pingclient.c cellular_app_sensors.c cellular_app_socket.c cellular_app_uiclient.c
    ../../../../../Misc/Samples/CellularIoT/Inc/: plf_cellular_app_iot_config.h plf_cellular_app_iot_thread_config.h
  group Utilities/LCD
    ../../../../../../Utilities/LCD/: stm32_lcd.c
software components: CMSIS:CORE 4.3.0
