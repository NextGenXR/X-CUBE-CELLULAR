<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\prj_STWINKT1.ewp</path>
  </project>
  <batchBuild />
</workspace>
